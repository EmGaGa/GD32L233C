# Keil uVision project GD32L233C_START.uvprojx, settings and files
target GD32L233C_START (6150000::V6.15::ARMCLANG)
  device: GD32L233CC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.0.0.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include;..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include;..\..\Utilities;..\..\Projects;..\source\inc;..\peripheral\led\inc;..\peripheral\usart\inc;..\peripheral\lcd;..\rt-thread\bsp;..\rt-thread\include\libc;..\rt-thread\include;..\rt-thread\components\finsh;..\peripheral\w25qxx;..\fatfs;..\peripheral\rotary\inc;..\peripheral\key;..\peripheral\ws2812;..\peripheral\tea5767
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32l23x_it.c systick.c
    ../rt-thread/bsp/: board.c rtconfig.h
  group GD32L23x_Peripherals
    ../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Startup
    ../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
  group peripheral
    ../peripheral/led/src/: led.c
    ../peripheral/usart/src/: usart.c
    ../peripheral/lcd/: lcd.c lcd_init.c
    ../peripheral/w25qxx/: w25qxx.c
    ../peripheral/rotary/src/: rotary.c
    ../peripheral/ws2812/: ws2812c.c
    ../peripheral/key/: key.c
    ../peripheral/tea5767/: tea5767.c iic.c timer2.c
  group Doc
    ../: readme.txt
  group rtt/port
    ../rt-thread/libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group rtt/source
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group fatfs
    ../fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.2.0
